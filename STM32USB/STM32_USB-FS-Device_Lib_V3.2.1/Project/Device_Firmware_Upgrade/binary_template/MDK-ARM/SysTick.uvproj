# Keil uVision project SysTick.uvproj, settings and files
target STM3210E-EVAL_XL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL_XL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210E_EVAL, STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xfe000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../src/: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_dma.c
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/: stm32_eval.c
  group Doc
    ../: readme.txt
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210E_EVAL, STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x7e000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210B_EVAL, STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x5000
